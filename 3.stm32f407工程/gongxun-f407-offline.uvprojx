# Keil uVision project gongxun-f407-offline.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gongxun-f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=1
  c include: .\CORE;.\USER;.\StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\HARDWARE\LED;.\HARDWARE\BUZZER;.\SYSTEM\USART;.\HARDWARE\KEY;.\HARDWARE\POWER;.\SYSTEM\CAN;.\SYSTEM\SAFETY;.\SYSTEM\WATCHDOG;.\HARDWARE\SCREEN;.\HARDWARE\SAOMA;.\HARDWARE\RADAR_SERVO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: motion_route_trial.h field_map.c route_config.h route_plan.h app_entry.c main.c FreeRTOSConfig.h freertos_hooks.c freertos_hooks.h motion_profile.c motion_profile.h chassis_odometry.c chassis_odometry.h chassis_kinematics.c chassis_kinematics.h chassis_direction_guard.h zdt_emm_config.h zdt_emm_protocol.h chassis_load_diag.h runtime_route.c runtime_route.h chassis_load_diag.c heading_controller.c heading_controller.h chassis_auto_test.c chassis_auto_test.h hwt101.c hwt101.h hwt101_parser.c hwt101_parser.h heading_session.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/BUZZER/: buzzer.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/POWER/: power.c
    ./HARDWARE/SCREEN/: screen.c
    ./HARDWARE/SAOMA/: saoma.c
  group SYSTEM
    ./SYSTEM/USART/: usart.c
    ./SYSTEM/CAN/: can.c
    ./SYSTEM/SAFETY/: safety.c
    ./SYSTEM/WATCHDOG/: watchdog.c
  group LIB
    ./StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c
  group CORE
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS
    ./FreeRTOS/: tasks.c list.c queue.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group RADAR_SERVO
    ./HARDWARE/RADAR_SERVO/: radar_servo.c radar_lift.c radar_servo_logic.c radar_zone_switch.c
    ./StdPeriph_Driver/src/: stm32f4xx_tim.c
