# Keil uVision project gongxun-f407.uvprojx, settings and files
target Vehicle_Integrated (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Vehicle_Integrated
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ICM45686_SAMPLE_ONLY=0,APP_CONTINUOUS_MAP_ENABLE=1,APP_MAP_NAV_RESIDUAL_ENABLE=1,APP_ZONE2_NAV_ENABLE=1,APP_ZONE2_NAV_MOTION_ENABLE=1,APP_ZONE2_MISSION_ENABLE=1,STARTUP_EXTENSION_HOME_TEST_ONLY=0,APP_ZONE2_POSE_TRACE_ENABLE=1,STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=0
  c include: .\CHASSIS\CORE;.\CHASSIS\USER;.\CHASSIS\StdPeriph_Driver\inc;.\CHASSIS\FreeRTOS\include;.\CHASSIS\FreeRTOS\portable\RVDS\ARM_CM4F;.\CHASSIS\HARDWARE\LED;.\CHASSIS\HARDWARE\BUZZER;.\CHASSIS\SYSTEM\USART;.\CHASSIS\HARDWARE\KEY;.\CHASSIS\HARDWARE\POWER;.\CHASSIS\SYSTEM\CAN;.\CHASSIS\SYSTEM\SAFETY;.\CHASSIS\SYSTEM\WATCHDOG;.\CHASSIS\HARDWARE\SCREEN;.\CHASSIS\HARDWARE\SAOMA;.\CHASSIS\HARDWARE\RADAR_SERVO;.\CHASSIS\HARDWARE\RADAR_V6;.\CHASSIS\HARDWARE\ICM45686;.\HARDWARE\GRIPPER;.\HARDWARE\CARRIER;.\HARDWARE\DM_CAN2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 00_现场参数
    ./USER/: vehicle_parameters.h
  group HARDWARE_机构
    ./HARDWARE/GRIPPER/: gripper.c
    ./HARDWARE/CARRIER/: carrier_pwm.c
  group DM_CAN2
    ./HARDWARE/DM_CAN2/: dm_can2.c dm_can2.h dm_can2_protocol.c dm_can2_motion.c
  group USER_整车
    ./CHASSIS/USER/: motion_route_trial.h field_map.c route_config.h route_plan.h app_entry.c main.c FreeRTOSConfig.h freertos_hooks.c freertos_hooks.h motion_profile.c motion_profile.h fusion_adapter.c fusion_adapter.h fusion_motion.c fusion_motion.h zone2_nav_path.c zone2_nav_path.h app_zone2.c zone2_motion_reference.c zone2_motion_reference.h zone2_nav_schedule.c zone2_nav_schedule.h fusion_reference.c fusion_reference.h chassis_odometry.c chassis_odometry.h chassis_kinematics.c chassis_kinematics.h chassis_direction_guard.h zdt_emm_config.h zdt_emm_protocol.h chassis_load_diag.h runtime_route.c runtime_route.h chassis_load_diag.c heading_controller.c heading_controller.h chassis_auto_test.c chassis_auto_test.h app_serial_runtime.c app_debug_runtime.c app_input_runtime.c app_chassis_service.c app_serial_runtime.h app_motion_runtime.c app_motion_runtime.h app_runtime_route.c app_runtime_route.h app_serial_internal.h app_translation_runtime.c app_translation_runtime.h app_heading_runtime.c app_heading_runtime.h app_motion_internal.h app_can_diagnostics.c app_can_diagnostics.h app_icm_observer.c app_fusion_capture.c app_odometry.c app_odometry.h heading_source.c heading_source.h hwt101.c hwt101.h hwt101_parser.c hwt101_parser.h heading_session.c startup_pose.c startup_axes.c lift_ruler_adapter.c lift_ruler_calibration.c source_parallel_flow.c source_stage2_owner.c source_stage2_runtime.c source_stage2_vision_bridge.c vehicle_arm.c
  group HARDWARE_底盘
    ./CHASSIS/HARDWARE/LED/: led.c
    ./CHASSIS/HARDWARE/BUZZER/: buzzer.c
    ./CHASSIS/HARDWARE/KEY/: key.c
    ./CHASSIS/HARDWARE/POWER/: power.c
    ./CHASSIS/HARDWARE/SCREEN/: screen.c
    ./CHASSIS/HARDWARE/SAOMA/: saoma.c
  group SYSTEM
    ./CHASSIS/SYSTEM/USART/: usart.c
    ./CHASSIS/SYSTEM/CAN/: can.c
    ./CHASSIS/SYSTEM/SAFETY/: safety.c
    ./CHASSIS/SYSTEM/WATCHDOG/: watchdog.c
  group StdPeriph
    ./CHASSIS/StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c
  group CORE
    ./CHASSIS/CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS
    ./CHASSIS/FreeRTOS/: tasks.c list.c queue.c
    ./CHASSIS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./CHASSIS/FreeRTOS/portable/MemMang/: heap_4.c
  group RADAR_SERVO
    ./CHASSIS/HARDWARE/RADAR_SERVO/: radar_servo.c radar_lift.c radar_servo_logic.c radar_zone_switch.c
    ./CHASSIS/HARDWARE/ICM45686/: icm45686_raw.c icm45686_port.c
    ./CHASSIS/StdPeriph_Driver/src/: stm32f4xx_tim.c
  group Radar_V6_Observer
    ./CHASSIS/HARDWARE/RADAR_V6/: link_protocol.c radar_client.c radar_uart_port.c radar_observer.c
target Vehicle_Offline (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Vehicle_Offline
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ICM45686_SAMPLE_ONLY=0,APP_CONTINUOUS_MAP_ENABLE=1,APP_MAP_NAV_RESIDUAL_ENABLE=1,APP_ZONE2_NAV_ENABLE=1,APP_ZONE2_NAV_MOTION_ENABLE=1,APP_ZONE2_MISSION_ENABLE=1,STARTUP_EXTENSION_HOME_TEST_ONLY=0,APP_ZONE2_POSE_TRACE_ENABLE=1,STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
