# Keil uVision project gongxun-f407.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gongxun-f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\CORE;.\USER;.\StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM4F;.\HARDWARE\LED;.\HARDWARE\BUZZER;.\SYSTEM\USART;.\HARDWARE\KEY;.\HARDWARE\POWER;.\SYSTEM\CAN;.\SYSTEM\SAFETY;.\SYSTEM\WATCHDOG;.\HARDWARE\SCREEN;.\HARDWARE\SAOMA;.\HARDWARE\GRIPPER;.\HARDWARE\LIFT;.\HARDWARE\EXTENSION;.\HARDWARE\DM_CAN2;.\HARDWARE\CARRIER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./USER/: main.c FreeRTOSConfig.h freertos_hooks.c freertos_hooks.h chassis_kinematics.c chassis_kinematics.h heading_controller.c heading_controller.h chassis_auto_test.c chassis_auto_test.h hwt101.c hwt101.h hwt101_parser.c hwt101_parser.h heading_session.c gripper_task.c gripper_task.h arm_power_mode.c arm_power_mode.h arm_sequence.c arm_sequence.h
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/BUZZER/: buzzer.c
    ./HARDWARE/KEY/: key.c
    ./HARDWARE/POWER/: power.c
    ./HARDWARE/SCREEN/: screen.c
    ./HARDWARE/SAOMA/: saoma.c
    ./HARDWARE/GRIPPER/: gripper.c gripper_config.h
    ./HARDWARE/CARRIER/: carrier.c carrier.h carrier_config.h carrier_pwm.c carrier_pwm.h
  group SYSTEM
    ./SYSTEM/USART/: usart.c
    ./SYSTEM/CAN/: can.c
    ./SYSTEM/SAFETY/: safety.c
    ./SYSTEM/WATCHDOG/: watchdog.c
  group LIB
    ./StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c stm32f4xx_tim.c
  group CORE
    ./CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS
    ./FreeRTOS/: tasks.c list.c queue.c
    ./FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group LIFT
    ./HARDWARE/LIFT/: lift.c lift.h lift_config.h lift_protocol.c lift_protocol.h lift_home.c lift_home.h
  group EXTENSION
    ./HARDWARE/EXTENSION/: extension.c extension.h extension_home.c extension_home.h
  group DM_CAN2
    ./HARDWARE/DM_CAN2/: dm_can2.c dm_can2.h dm_can2_protocol.c dm_can2_motion.c
  group Chassis_USER
    ./CHASSIS/USER/: motion_route_trial.h field_map.c route_config.h route_plan.h app_entry.c main.c FreeRTOSConfig.h freertos_hooks.c freertos_hooks.h motion_profile.c motion_profile.h chassis_odometry.c chassis_odometry.h chassis_kinematics.c chassis_kinematics.h chassis_direction_guard.h zdt_emm_config.h zdt_emm_protocol.h chassis_load_diag.h runtime_route.c runtime_route.h chassis_load_diag.c heading_controller.c heading_controller.h chassis_auto_test.c chassis_auto_test.h hwt101.c hwt101.h hwt101_parser.c hwt101_parser.h heading_session.c
  group Chassis_HARDWARE
    ./CHASSIS/HARDWARE/LED/: led.c
    ./CHASSIS/HARDWARE/BUZZER/: buzzer.c
    ./CHASSIS/HARDWARE/KEY/: key.c
    ./CHASSIS/HARDWARE/POWER/: power.c
    ./CHASSIS/HARDWARE/SCREEN/: screen.c
    ./CHASSIS/HARDWARE/SAOMA/: saoma.c
  group Chassis_SYSTEM
    ./CHASSIS/SYSTEM/USART/: usart.c
    ./CHASSIS/SYSTEM/CAN/: can.c
    ./CHASSIS/SYSTEM/SAFETY/: safety.c
    ./CHASSIS/SYSTEM/WATCHDOG/: watchdog.c
  group Chassis_LIB
    ./CHASSIS/StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c
  group Chassis_CORE
    ./CHASSIS/CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group Chassis_FreeRTOS
    ./CHASSIS/FreeRTOS/: tasks.c list.c queue.c
    ./CHASSIS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ./CHASSIS/FreeRTOS/portable/MemMang/: heap_4.c
  group Chassis_RADAR_SERVO
    ./CHASSIS/HARDWARE/RADAR_SERVO/: radar_servo.c radar_lift.c radar_servo_logic.c radar_zone_switch.c
    ./CHASSIS/StdPeriph_Driver/src/: stm32f4xx_tim.c
target Chassis_Stage1_Emm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Chassis_Stage1_Emm
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=0
  c include: .\CHASSIS\CORE;.\CHASSIS\USER;.\CHASSIS\StdPeriph_Driver\inc;.\CHASSIS\FreeRTOS\include;.\CHASSIS\FreeRTOS\portable\RVDS\ARM_CM4F;.\CHASSIS\HARDWARE\LED;.\CHASSIS\HARDWARE\BUZZER;.\CHASSIS\SYSTEM\USART;.\CHASSIS\HARDWARE\KEY;.\CHASSIS\HARDWARE\POWER;.\CHASSIS\SYSTEM\CAN;.\CHASSIS\SYSTEM\SAFETY;.\CHASSIS\SYSTEM\WATCHDOG;.\CHASSIS\HARDWARE\SCREEN;.\CHASSIS\HARDWARE\SAOMA;.\CHASSIS\HARDWARE\RADAR_SERVO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target Chassis_Stage1_Offline (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Chassis_Stage1_Offline
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
