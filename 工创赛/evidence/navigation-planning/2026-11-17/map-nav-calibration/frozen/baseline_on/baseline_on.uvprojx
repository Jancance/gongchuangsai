# Keil uVision project baseline_on.uvprojx, settings and files
target Vehicle_Integrated (5060960::V5.06 update 7 (build 960)::D:\Desktop\工创赛\3.stm32f407工程\arm5_compiler)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Vehicle_Integrated
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ICM45686_SAMPLE_ONLY=0,APP_CONTINUOUS_MAP_ENABLE=1,APP_MAP_NAV_RESIDUAL_ENABLE=1,APP_LEFT_NAV_RESIDUAL_ENABLE=1,APP_DIRECTION_NAV_RESIDUAL_ENABLE=1,APP_MAIN_NAV_RESIDUAL_ENABLE=1,APP_CONTROL_DISTANCE_RATIO_ENABLE=1,APP_RIGHT40_FORWARD_TRIM_ENABLE=1,APP_TURN90_90_ENABLE=1,APP_TURN_BRAKE_TRIAL_DPS=90,APP_VM_CALIBRATION_ONLY_ENABLE=0,APP_VM_ONLY_ENABLE=0,APP_WHEEL_ENABLE_HOLD_ENABLE=0,APP_LEFT40_DRIFT_TRIM_ENABLE=1,APP_BASELINE40_ENABLE=1,VEHICLE_INTEGRATED_ENABLE=0,VEHICLE_STAGE1_ENABLE=0,APP_FUSION_CAPTURE_STATIC_TEST=0,APP_FUSION_CAPTURE_ENABLE=1,STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=0
  c include: D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\CORE;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\USER;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\StdPeriph_Driver\inc;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\FreeRTOS\include;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\FreeRTOS\portable\RVDS\ARM_CM4F;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\LED;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\BUZZER;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\SYSTEM\USART;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\KEY;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\POWER;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\SYSTEM\CAN;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\SYSTEM\SAFETY;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\SYSTEM\WATCHDOG;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\SCREEN;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\SAOMA;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\RADAR_SERVO;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\RADAR_V6;D:\Desktop\工创赛\3.stm32f407工程\CHASSIS\HARDWARE\ICM45686;D:\Desktop\工创赛\3.stm32f407工程\HARDWARE\GRIPPER;D:\Desktop\工创赛\3.stm32f407工程\HARDWARE\CARRIER;D:\Desktop\工创赛\3.stm32f407工程\HARDWARE\DM_CAN2
  asm define: ICM45686_SAMPLE_ONLY=0,APP_CONTINUOUS_MAP_ENABLE=1,APP_MAP_NAV_RESIDUAL_ENABLE=1,APP_LEFT_NAV_RESIDUAL_ENABLE=1,APP_DIRECTION_NAV_RESIDUAL_ENABLE=1,APP_MAIN_NAV_RESIDUAL_ENABLE=1,APP_CONTROL_DISTANCE_RATIO_ENABLE=1,APP_RIGHT40_FORWARD_TRIM_ENABLE=1,APP_TURN90_90_ENABLE=1,APP_TURN_BRAKE_TRIAL_DPS=90,APP_VM_CALIBRATION_ONLY_ENABLE=0,APP_VM_ONLY_ENABLE=0,APP_WHEEL_ENABLE_HOLD_ENABLE=0,APP_LEFT40_DRIFT_TRIM_ENABLE=1,APP_BASELINE40_ENABLE=1,VEHICLE_INTEGRATED_ENABLE=0,VEHICLE_STAGE1_ENABLE=0,APP_FUSION_CAPTURE_STATIC_TEST=0,APP_FUSION_CAPTURE_ENABLE=1,
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 00_现场参数
    D:/Desktop/工创赛/3.stm32f407工程/USER/: vehicle_parameters.h
  group HARDWARE_机构
    D:/Desktop/工创赛/3.stm32f407工程/HARDWARE/GRIPPER/: gripper.c
    D:/Desktop/工创赛/3.stm32f407工程/HARDWARE/CARRIER/: carrier_pwm.c
  group DM_CAN2
    D:/Desktop/工创赛/3.stm32f407工程/HARDWARE/DM_CAN2/: dm_can2.c dm_can2.h dm_can2_protocol.c dm_can2_motion.c
  group USER_整车
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/USER/: motion_route_trial.h field_map.c route_config.h route_plan.h app_entry.c main.c FreeRTOSConfig.h freertos_hooks.c freertos_hooks.h motion_profile.c motion_profile.h chassis_odometry.c chassis_odometry.h chassis_kinematics.c chassis_kinematics.h chassis_direction_guard.h zdt_emm_config.h zdt_emm_protocol.h chassis_load_diag.h runtime_route.c runtime_route.h chassis_load_diag.c heading_controller.c heading_controller.h chassis_auto_test.c chassis_auto_test.h app_serial_runtime.c app_debug_runtime.c app_input_runtime.c app_chassis_service.c app_serial_runtime.h app_motion_runtime.c app_motion_runtime.h app_runtime_route.c app_runtime_route.h app_serial_internal.h app_translation_runtime.c app_translation_runtime.h app_heading_runtime.c app_heading_runtime.h app_motion_internal.h app_can_diagnostics.c app_can_diagnostics.h app_icm_observer.c app_fusion_capture.c app_odometry.c app_odometry.h heading_source.c heading_source.h hwt101.c hwt101.h hwt101_parser.c hwt101_parser.h heading_session.c startup_pose.c startup_axes.c vehicle_arm.c
  group HARDWARE_底盘
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/LED/: led.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/BUZZER/: buzzer.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/KEY/: key.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/POWER/: power.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/SCREEN/: screen.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/SAOMA/: saoma.c
  group SYSTEM
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/SYSTEM/USART/: usart.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/SYSTEM/CAN/: can.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/SYSTEM/SAFETY/: safety.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/SYSTEM/WATCHDOG/: watchdog.c
  group StdPeriph
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c misc.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_iwdg.c stm32f4xx_dbgmcu.c
  group CORE
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/CORE/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group FreeRTOS
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/FreeRTOS/: tasks.c list.c queue.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/FreeRTOS/portable/MemMang/: heap_4.c
  group RADAR_SERVO
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/RADAR_SERVO/: radar_servo.c radar_lift.c radar_servo_logic.c radar_zone_switch.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/ICM45686/: icm45686_raw.c icm45686_port.c
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/StdPeriph_Driver/src/: stm32f4xx_tim.c
  group Radar_V6_Observer
    D:/Desktop/工创赛/3.stm32f407工程/CHASSIS/HARDWARE/RADAR_V6/: link_protocol.c radar_client.c radar_uart_port.c radar_observer.c
target Vehicle_Offline (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: as above
  output: Vehicle_Offline
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ICM45686_SAMPLE_ONLY=0,APP_CONTINUOUS_MAP_ENABLE=1,APP_MAP_NAV_RESIDUAL_ENABLE=1,APP_LEFT_NAV_RESIDUAL_ENABLE=1,APP_DIRECTION_NAV_RESIDUAL_ENABLE=1,APP_MAIN_NAV_RESIDUAL_ENABLE=1,APP_CONTROL_DISTANCE_RATIO_ENABLE=1,APP_RIGHT40_FORWARD_TRIM_ENABLE=1,APP_TURN90_90_ENABLE=1,APP_TURN_BRAKE_TRIAL_DPS=90,APP_VM_CALIBRATION_ONLY_ENABLE=0,APP_VM_ONLY_ENABLE=0,APP_WHEEL_ENABLE_HOLD_ENABLE=0,APP_LEFT40_DRIFT_TRIM_ENABLE=1,APP_BASELINE40_ENABLE=1,VEHICLE_INTEGRATED_ENABLE=0,VEHICLE_STAGE1_ENABLE=0,APP_FUSION_CAPTURE_STATIC_TEST=0,APP_FUSION_CAPTURE_ENABLE=1,STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,APP_MOTOR_OFFLINE_ONLY=1
  c include: as above
  asm define: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
